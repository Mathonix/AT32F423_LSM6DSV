# Keil uVision project lsm6dsv_spi_test.uvprojx, settings and files
target lsm6dsv_spi_test (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: AT32F423KCU7-4 ArteryTek
  pack: ArteryTek.AT32F423_DFP.2.1.2
  cpu: IRAM(0x20000000,0xC000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: lsm6dsv_spi_test +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: AT32F423KCU7_4,USE_STDPERIPH_DRIVER,VQF_SINGLE_PRECISION
  c include: ..\inc;..\inc\app;..\inc\bsp;..\inc\calibration;..\inc\config;..\inc\diagnostics;..\inc\drivers;..\inc\fusion;..\inc\telemetry;..\AT32F423_Firmware_Library\libraries\cmsis\cm4\core_support;..\AT32F423_Firmware_Library\libraries\cmsis\cm4\device_support;..\AT32F423_Firmware_Library\libraries\drivers\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group user
    ../src/app/: main.c
    ../src/bsp/: bsp.c ws2812.c at32f423_clock.c at32f423_int.c
    ../src/drivers/: lsm6dsv.c ist8310.c can_test.c usb_cdc.c
    ../src/fusion/: vqf_wrapper.cpp vqf_full.cpp
  group firmware
    ../AT32F423_Firmware_Library/libraries/drivers/src/: at32f423_crm.c at32f423_gpio.c at32f423_misc.c at32f423_spi.c at32f423_usart.c at32f423_flash.c at32f423_pwc.c at32f423_dma.c at32f423_can.c at32f423_usb.c
  group cmsis
    ../AT32F423_Firmware_Library/libraries/cmsis/cm4/device_support/: system_at32f423.c
    ../AT32F423_Firmware_Library/libraries/cmsis/cm4/device_support/startup/mdk/: startup_at32f423.s
  group readme
    ../: README.md
